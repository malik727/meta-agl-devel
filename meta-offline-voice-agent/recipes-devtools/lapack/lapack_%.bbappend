EXTRA_OECMAKE:append = " -DBUILD_SHARED_LIBS=ON -DBUILD_TESTING=OFF -DLAPACKE=ON -DLAPACKE_WITH_TMG=ON "
