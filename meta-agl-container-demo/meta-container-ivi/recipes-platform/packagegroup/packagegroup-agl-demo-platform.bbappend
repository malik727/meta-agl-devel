#
# Demo: reboot container, reboot system
#
RDEPENDS_${PN} += "\
   circular-progress-bar \
   lxc-guest-demo \
   "
