IMAGE_INSTALL_append = " \
    packagegroup-agl-container-lxc-guest \
    "