FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-backend-wayland-Disable-frame-repaint.patch"
