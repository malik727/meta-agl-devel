RRECOMMENDS_${PN} += "\
    lxc-launcher \
    "
